# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: main +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c 24c02.c delay.c image.c keyboard.c lcd12864.c mxled.c mymenu.c softreset.c usecommunication.c wt588d.c
